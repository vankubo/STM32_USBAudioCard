# Keil uVision project f411_usbAudio.uvprojx, settings and files
target f411_usbAudio (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f411_usbAudio +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,STM32F4XX,ARM_MATH_CM4
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MALLOC;..\HARDWARE\I2S;..\HARDWARE\IIC;..\HARDWARE\LED;..\HARDWARE\WM8978;..\HARDWARE\SPI;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\audio\inc;..\HARDWARE\tftlcd;..\HARDWARE\DMA;..\HARDWARE\framebuffer;.\Include;..\HARDWARE\gui;..\HARDWARE\ADC;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c arm_cortexM4lf_math.lib
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/tftlcd/: Lcd_Driver.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/framebuffer/: framebuffer.c
    ../HARDWARE/gui/: GUI.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_exti.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/audio/src/: usbd_audio_core.c usbd_audio_out_if.c
  group USB_APP
    ../USB/USB_APP/: stm324xg_usb_audio_codec.c usb_bsp.c usbd_desc.c usbd_usr.c
